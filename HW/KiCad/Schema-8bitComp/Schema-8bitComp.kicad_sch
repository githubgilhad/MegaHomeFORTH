File: HW/KiCad/Schema-8bitComp/Schema-8bitComp.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Silkscreen, views
Other:
- note added: "For Arduino A / the same for B"
